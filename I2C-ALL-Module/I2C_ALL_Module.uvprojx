# Keil uVision project I2C_ALL_Module.uvprojx, settings and files
target Temp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx,HSE_VALUE = 8000000
  c include: .\USER;.\SCR;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group SCR
    ./SCR/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group USER
    ./USER/: i2c_f4.c usart2.c i2c_ds1307.c i2c_mpu6050.c i2c_pcf8574.c i2c_tcs34725.c f4_ssd1306.c f4_fonts.c horse_anim.h bitmap.h f4_mcp23017.c f4_sys_tick.c
  group START_UP
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f446xx.s
  group STD_Lib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_syscfg.c misc.c
